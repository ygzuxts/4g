# Keil uVision project 4GCatModule.uvprojx, settings and files
target 4GCatModule (5060960::V5.06 update 7 (build 960)::.\ARM5.06)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 4GCatModule +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;..\Middlewares\Mavlink;..\Middlewares\Mavlink\common;..\Middlewares\Mavlink\minimal;..\Middlewares\FatFs;..\Middlewares\FatFs\drivers;..\Middlewares\FatFs\option
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group BSP
    ../BSP/: cJSON.c usart_4gmoudle.c usart_debug.c usart_mavlink.c track_queue.c track_json.c rtcm_parse.c bsp_sdio_sd.c bsp_led.c bsp_Flash.c
  group Mavlink
    ../BSP/: mavlink_usart_fifo.c
    ../Middlewares/Mavlink/: mavlink_parse.c checksum.h define.h mavlink_conversions.h mavlink_get_info.h mavlink_helpers.h mavlink_sha256.h mavlink_types.h open_tel_mavlink.h protocol.h
    ../Middlewares/Mavlink/minimal/: mavlink.h mavlink_msg_heartbeat.h mavlink_msg_protocol_version.h minimal.h testsuite.h version.h
    ../Middlewares/Mavlink/common/: common.h mavlink_msg_actuator_control_target.h mavlink_msg_actuator_output_status.h mavlink_msg_adsb_vehicle.h mavlink_msg_ais_vessel.h mavlink_msg_altitude.h mavlink_msg_att_pos_mocap.h mavlink_msg_attack_status.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_attitude_quaternion_cov.h mavlink_msg_attitude_target.h mavlink_msg_auth_key.h mavlink_msg_autopilot_state_for_gimbal_device.h mavlink_msg_autopilot_version.h mavlink_msg_battery_status.h mavlink_msg_button_change.h mavlink_msg_camera_capture_status.h mavlink_msg_camera_fov_status.h mavlink_msg_camera_image_captured.h mavlink_msg_camera_information.h mavlink_msg_camera_pod_control.h mavlink_msg_camera_pod_states.h mavlink_msg_camera_settings.h mavlink_msg_camera_tracking_geo_status.h mavlink_msg_camera_tracking_image_status.h mavlink_msg_camera_trigger.h mavlink_msg_can_filter_modify.h mavlink_msg_can_frame.h mavlink_msg_canfd_frame.h mavlink_msg_cellular_config.h mavlink_msg_cellular_status.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_collision.h mavlink_msg_command_ack.h mavlink_msg_command_cancel.h mavlink_msg_command_int.h mavlink_msg_command_long.h mavlink_msg_component_information.h mavlink_msg_component_metadata.h mavlink_msg_control_system_state.h mavlink_msg_current_event_sequence.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_float_array.h mavlink_msg_debug_vect.h mavlink_msg_distance_sensor.h mavlink_msg_efi_status.h mavlink_msg_encapsulated_data.h mavlink_msg_esc_info.h mavlink_msg_esc_status.h mavlink_msg_estimator_status.h mavlink_msg_event.h mavlink_msg_extended_sys_state.h mavlink_msg_fence_status.h mavlink_msg_file_transfer_protocol.h mavlink_msg_flight_information.h mavlink_msg_flight_num_msg.h mavlink_msg_fmt_global_pos.h mavlink_msg_fmt_pos_yaw.h mavlink_msg_follow_target.h mavlink_msg_formation_config.h mavlink_msg_formation_set.h mavlink_msg_fuze_control.h mavlink_msg_fuze_states.h mavlink_msg_generator_status.h mavlink_msg_gimbal_device_attitude_status.h mavlink_msg_gimbal_device_information.h mavlink_msg_gimbal_device_set_attitude.h mavlink_msg_gimbal_manager_information.h mavlink_msg_gimbal_manager_set_attitude.h mavlink_msg_gimbal_manager_set_manual_control.h mavlink_msg_gimbal_manager_set_pitchyaw.h mavlink_msg_gimbal_manager_status.h mavlink_msg_global_position_int.h mavlink_msg_global_position_int_cov.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_input.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_rtcm_data.h mavlink_msg_gps_rtk.h mavlink_msg_gps_status.h mavlink_msg_gps2_raw.h mavlink_msg_gps2_rtk.h mavlink_msg_high_latency.h mavlink_msg_high_latency2.h mavlink_msg_highres_imu.h mavlink_msg_hil_actuator_controls.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_home_position.h mavlink_msg_hygrometer_sensor.h mavlink_msg_isbd_link_status.h mavlink_msg_landing_target.h mavlink_msg_link_node_status.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_cov.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_logging_ack.h mavlink_msg_logging_data.h mavlink_msg_logging_data_acked.h mavlink_msg_mag_cal_report.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_message_interval.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_int.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_int.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_mount_orientation.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_obstacle_distance.h mavlink_msg_odometry.h mavlink_msg_onboard_computer_status.h mavlink_msg_open_drone_id_authentication.h mavlink_msg_open_drone_id_basic_id.h mavlink_msg_open_drone_id_location.h mavlink_msg_open_drone_id_message_pack.h mavlink_msg_open_drone_id_operator_id.h mavlink_msg_open_drone_id_self_id.h mavlink_msg_open_drone_id_system.h mavlink_msg_optical_flow.h mavlink_msg_optical_flow_rad.h mavlink_msg_orbit_execution_status.h mavlink_msg_param_ext_ack.h mavlink_msg_param_ext_request_list.h mavlink_msg_param_ext_request_read.h mavlink_msg_param_ext_set.h mavlink_msg_param_ext_value.h mavlink_msg_param_map_rc.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_play_tune.h mavlink_msg_play_tune_v2.h mavlink_msg_position_target_global_int.h mavlink_msg_position_target_local_ned.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_raw_rpm.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_request_event.h mavlink_msg_resource_request.h mavlink_msg_response_event_error.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_imu3.h mavlink_msg_scaled_pressure.h mavlink_msg_scaled_pressure2.h mavlink_msg_scaled_pressure3.h mavlink_msg_serial_control.h mavlink_msg_serial_number_item.h mavlink_msg_serial_number_request.h mavlink_msg_servo_output_raw.h mavlink_msg_set_actuator_control_target.h mavlink_msg_set_attitude_target.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_home_position.h mavlink_msg_set_mode.h mavlink_msg_set_position_target_global_int.h mavlink_msg_set_position_target_local_ned.h mavlink_msg_setup_signing.h mavlink_msg_sim_state.h mavlink_msg_smart_battery_info.h mavlink_msg_statustext.h mavlink_msg_storage_information.h mavlink_msg_supported_tunes.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_target_position.h mavlink_msg_terrain_check.h mavlink_msg_terrain_data.h mavlink_msg_terrain_report.h mavlink_msg_terrain_request.h mavlink_msg_time_estimate_to_target.h mavlink_msg_timesync.h mavlink_msg_trajectory_representation_bezier.h mavlink_msg_trajectory_representation_waypoints.h mavlink_msg_tunnel.h mavlink_msg_uavcan_node_info.h mavlink_msg_uavcan_node_status.h mavlink_msg_utm_global_position.h mavlink_msg_v2_extension.h mavlink_msg_vfr_hud.h mavlink_msg_vibration.h mavlink_msg_vicon_position_estimate.h mavlink_msg_video_stream_information.h mavlink_msg_video_stream_status.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h mavlink_msg_wheel_distance.h mavlink_msg_wifi_config_ap.h mavlink_msg_winch_status.h mavlink_msg_wind_cov.h mavlink_msg_available_modes.h mavlink_msg_available_modes_monitor.h mavlink_msg_battery_info.h mavlink_msg_camera_thermal_range.h mavlink_msg_component_information_basic.h mavlink_msg_current_mode.h mavlink_msg_fuel_status.h mavlink_msg_illuminator_status.h mavlink_msg_open_drone_id_arm_status.h mavlink_msg_open_drone_id_system_update.h mavlink_msg_param_error.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FATFS
    ../Middlewares/FatFs/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/FatFs/drivers/: sd_diskio.c
    ../Middlewares/FatFs/option/: ccsbcs.c syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group readme
    ../: readme.md
software components: CMSIS:CORE 5.5.0
